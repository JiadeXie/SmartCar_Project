# Keil uVision project echo.uvproj, settings and files
target echo (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: echo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source;.\source\echo;.\source\public;.\source\display;.\source\motor;.\source\servo;.\source\ir_trace;.\source\bluetooth;.\source\main;.\source\ir_avoidance
  group echo
    ./source/echo/: echo.c echo.h
  group public
    ./source/public/: public.c public.h
  group display
    ./source/display/: display.c display.h
  group motor
    ./source/motor/: motor.c motor.h
  group servo
    ./source/servo/: servo.c servo.h
  group ir_trace
    ./source/ir_trace/: IR_Trace.c IR_Trace.h
  group bluetooth
    ./source/bluetooth/: bt.c bt.h
  group main
    ./source/main/: main.c
  group ir_avoid
    ./source/ir_avoidance/: avoid.c avoid.h
